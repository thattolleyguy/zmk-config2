## boards/shields/ahokore/Kconfig.defconfig
```kconfig
if SHIELD_AHOKORE

config ZMK_KEYBOARD_NAME
    default "ahokore"

endif # SHIELD_AHOKORE
```
